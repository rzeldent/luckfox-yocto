# Upstream rkmpp does not supply the RV110x proprietary encoder interface.
PACKAGECONFIG:remove = "rkmpp"
