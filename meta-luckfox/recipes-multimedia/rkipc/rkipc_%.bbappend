# This source application links proprietary SDK libraries and needs opaque
# encoder kernel payloads, which are deliberately not provided by this layer.
LICENSE = "BSD-3-Clause & CLOSED"
LICENSE_FLAGS += "luckfox-proprietary"
