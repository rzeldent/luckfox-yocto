LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""
LICENSE_FLAGS += "luckfox-proprietary"
